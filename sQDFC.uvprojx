# Keil uVision project sQDFC.uvprojx, settings and files
target sQDFC (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  output: sQDFC
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: STM32F405xx,USE_HAL_DRIVER
  c include: .;sAPP;sBSP;sDRV;sLIB;sUSER;sLIB\CMSIS\Include;sLIB\STM32F4xx_HAL_Driver\Inc;sLIB\sightseerUtils;sLIB\FreeRTOS\include;sLIB\FreeRTOS;sLIB\FreeRTOS\portable\GCC;sLIB\MadgwickAHRS;sLIB\cm_backtrace
  asm define: STM32F405xx,USE_HAL_DRIVER
  memory RVCT1: RAM 0x08000000 size 0x00100000
  memory RVCT6: RAM 0x20000000 size 0x00020000
  memory RVCT7: RAM 0x10000000 size 0x00010000
  group SAPP
    sAPP/: sAPP_AHRS.cpp sAPP_CLI.cpp sAPP_Debug.c sAPP_ParamSave.cpp sAPP_Tasks.cpp
  group SAPP/EKF_ALTEST6
    sAPP/ekf_AltEst6/: dot.c ekf_AltEst6.c ekf_AltEst6_data.c ekf_AltEst6_initialize.c ekf_AltEst6_terminate.c mldivide.c mrdivide_helper.c norm.c rk4_AltEst3.c rk4_AltEst3_data.c rk4_AltEst3_initialize.c rk4_AltEst3_terminate.c
  group SBSP
    sBSP/: sBSP_DMA.c sBSP_GPIO.c sBSP_I2C.c sBSP_RCC.c sBSP_SPI.c sBSP_TIM.c sBSP_UART.c
  group SDRV
    sDRV/: sDRV_DSHOT.cpp sDRV_ICM45686.c sDRV_LIS3MDLTR.c sDRV_MB85RCxx.c sDRV_SPL06.c SPL06001.c
  group SLIB/STM32F4XX_HAL_DRIVER/SRC
    sLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group SLIB/SIGHTSEERUTILS
    sLIB/sightseerUtils/: sUtils.c sUtils_Log.c
  group SLIB/MADGWICKAHRS
    sLIB/MadgwickAHRS/: MadgwickAHRS.c
  group SLIB/FREERTOS-PLUS-CLI
    sLIB/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
  group SLIB/FREERTOS/SRC
    sLIB/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group SLIB/FREERTOS/PORTABLE/MEMMANG
    sLIB/FreeRTOS/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4 - 副本.c heap_4.c heap_5.c
  group SLIB/FREERTOS/PORTABLE/GCC
    sLIB/FreeRTOS/portable/GCC/: port.c
  group SLIB/CM_BACKTRACE
    sLIB/cm_backtrace/: cm_backtrace.c
  group SLIB/CM_BACKTRACE/FAULT_HANDLER/KEIL
    sLIB/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group SLIB/CM_BACKTRACE/FAULT_HANDLER/IAR
    sLIB/cm_backtrace/fault_handler/iar/: cmb_fault.S
  group SLIB/CM_BACKTRACE/FAULT_HANDLER/GCC
    sLIB/cm_backtrace/fault_handler/gcc/: cmb_fault.S
  group SUSER
    sUSER/: main.cpp startup_stm32f405xx.s stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c stm32_hal_msp.c system_stm32f4xx.c
